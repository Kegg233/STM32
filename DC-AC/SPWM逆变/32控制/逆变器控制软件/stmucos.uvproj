# Keil uVision project stmucos.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 方向盘 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD
  c include: .\APP;.\STM32LIB\includes;.\uCOS-II\Ports;.\uCOS-II\Source;.\FATFS;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./APP/: main.c stm32f10x_it.c spwm.c
  group BSP
    ./BSP/: led.c adc.c Timer.c eeprom.c jiami.c ST7565S.c serial.c
  group STM32LIB
    ./STM32LIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_dma.c
    ./APP/: system_stm32f10x.c
    ./STM32LIB/startup/arm/: startup_stm32f10x_hd.s
  group uCOS-II/ports
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
